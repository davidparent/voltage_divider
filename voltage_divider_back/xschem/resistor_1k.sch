v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/res.sym} 0 0 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {devices/iopin.sym} 0 -70 0 0 {name=p1 lab=1}
C {devices/iopin.sym} 0 60 0 0 {name=p2 lab=2}
